# Keil uVision project SECOND_SONSOR.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC89C58RD+ Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: SECOND_SONSOR +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
