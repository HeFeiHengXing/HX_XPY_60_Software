# Keil uVision project hello.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: hello +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 DS18B20.C MAIN.c
